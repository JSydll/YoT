# -------------------
# Adjustments to the basic configuration files
# -------------------

# Depends on the following custom env vars exported to the yocto build:
# - SETTINGS_HOSTNAME

hostname="${SETTINGS_HOSTNAME}"