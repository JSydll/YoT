# -------------------
# Provides a target specific fstab configuration with boot and media partition
# -------------------

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"